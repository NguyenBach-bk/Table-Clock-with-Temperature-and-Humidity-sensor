# Keil uVision project 8051_Digital_Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 8051_Digital_Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 8051_Digital_Clock.c
    ../Lib/: LCD_16_2.c Delay.c LCD_16_2.h Delay.h I2C.c I2C.h DS1307.c DS1307.h DHT11.c DHT11.h
